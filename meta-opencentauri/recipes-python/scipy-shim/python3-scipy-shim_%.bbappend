# Empty bbappend for scipy-shim (extends native recipe only)

SUMMARY = "A Python parser for parsing multipart/form-data input chunks"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=0cf3746abe7520a6d19dbbeb18832eb0"

PYPI_PACKAGE = "streaming_form_data"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "cab18e7b5d31e79ac6ec71a5f2e880aafdd90321bd2197955fd7fdbd7f3e2101"

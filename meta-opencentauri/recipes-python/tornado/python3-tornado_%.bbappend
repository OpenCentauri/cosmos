RDEPENDS:${PN}:remove = "python3-unittest"

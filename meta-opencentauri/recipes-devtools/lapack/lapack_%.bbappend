PACKAGECONFIG:append = " lapacke"
BBCLASSEXTEND = "native"

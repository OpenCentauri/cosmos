FILESEXTRAPATHS:prepend := "${THISDIR}/python3-numpy:"

SRC_URI += "file://0001-Lazy-load-heavy-public-subpackages.patch"

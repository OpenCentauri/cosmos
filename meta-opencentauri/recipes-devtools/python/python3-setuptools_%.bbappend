FILESEXTRAPATHS:prepend := "${THISDIR}/python3-setuptools:"

SRC_URI += "file://0001-build_ext-take-abi3-suffix-from-sysconfig.patch"

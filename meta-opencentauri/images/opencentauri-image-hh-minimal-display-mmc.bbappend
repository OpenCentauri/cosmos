# Add WiFi power management disable package
IMAGE_INSTALL:append = " disable-wifi-powersave"

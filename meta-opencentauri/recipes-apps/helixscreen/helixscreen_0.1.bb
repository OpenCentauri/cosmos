SUMMARY = "HelixScreen - Interface for Klipper"
DESCRIPTION = "A modern, lightweight touchscreen interface for Klipper 3D printers"
HOMEPAGE = "https://github.com/prestonbrown/helixscreen"
LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1ebbd3e34237af26da5dc08a4e440464"

SRC_URI = "gitsm://github.com/prestonbrown/helixscreen.git;protocol=https;branch=main"
SRCREV = "3aa8d5f6d904e7e66bfd0d647802a85f49317e02"

inherit pkgconfig

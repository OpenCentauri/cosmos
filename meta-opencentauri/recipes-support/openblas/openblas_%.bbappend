PACKAGECONFIG:remove = "openmp"
PACKAGECONFIG:append = " lapack"
